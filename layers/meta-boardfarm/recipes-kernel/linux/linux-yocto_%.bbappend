COMPATIBLE_MACHINE:rock-5t = "rock-5t"