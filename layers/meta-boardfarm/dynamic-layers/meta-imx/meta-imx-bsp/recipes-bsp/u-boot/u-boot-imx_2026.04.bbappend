DEPENDS:append = " efitools-native"