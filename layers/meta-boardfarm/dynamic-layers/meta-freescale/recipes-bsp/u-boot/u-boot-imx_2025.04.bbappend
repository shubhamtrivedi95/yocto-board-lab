DEPENDS += "elfutils-native"