do_compile[vardeps] += "OS_RELEASE_SIGNATURE"

OS_RELEASE_SIGNATURE = "\
${DISTRO}|\
${DISTRO_NAME}|\
${DISTRO_VERSION}|\
${DISTRO_CODENAME}"
