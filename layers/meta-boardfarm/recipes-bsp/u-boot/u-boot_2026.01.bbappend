FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:rock-5t = " file://0001-configs-Add-rock5t-rk3588_defconfig-for-Rockchip-RK3.patch"

